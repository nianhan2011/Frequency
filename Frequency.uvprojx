# Keil uVision project Frequency.uvprojx, settings and files
target Frequency (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Frequency +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\HARDWARE\LCD;.\HARDWARE\LED;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\dht11;.\SYSTEM\TIMER;.\STM32F10x_FWLib\src;.\HARDWARE\Ethernet\Internet;.\HARDWARE\Ethernet\W5500;.\HARDWARE\TimBase;.\HARDWARE\GM331H_4G;.\SYSTEM\Common;.\SYSTEM\os_system;.\HARDWARE\samkoon;.\SYSTEM\queue;.\HARDWARE\key;.\HARDWARE\vdf
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./USER/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group HARDWARE
    ./HARDWARE/LCD/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h pic.h
    ./HARDWARE/LED/: led.c led.h
    ./HARDWARE/dht11/: bsp_dht11.c bsp_dht11.h
    ./HARDWARE/Ethernet/Internet/: dhcp.c dhcp.h tcp_demo.c tcp_demo.h
    ./HARDWARE/Ethernet/W5500/: socket.c socket.h types.h utility.c utility.h w5500.c w5500.h w5500_conf.c w5500_conf.h
    ./HARDWARE/TimBase/: bsp_TiMbase.c bsp_TiMbase.h
    ./HARDWARE/GM331H_4G/: bsp_4G.c bsp_4G.h
    ./HARDWARE/samkoon/: sk_hmi.c sk_hmi.h usart3.c usart3.h
    ./HARDWARE/key/: key.c key.h
    ./HARDWARE/vdf/: usart2.h vdf_710.c vdf_710.h usart2.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c delay.h
    ./SYSTEM/usart/: usart.c usart.h
    ./SYSTEM/TIMER/: timer.c timer.h
    ./SYSTEM/Common/: Common.c Common.h
    ./SYSTEM/os_system/: os_system.h os_system.c
    ./SYSTEM/queue/: queue.c queue.h
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./STM32F10x_FWLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group CORE
    ./CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
